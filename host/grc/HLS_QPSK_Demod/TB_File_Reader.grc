options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: TB_File_Reader
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sdr/workspace/puch-workspace/HLS-QPSK-Demod-Baseband_002/fpga/lib/HLS_QPSK_Demod/sim/0xDEADBEEF_Rx_Samps.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://192.168.1.13:10000
    timeout: '1000'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

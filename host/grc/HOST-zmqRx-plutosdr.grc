options:
  parameters:
    generate_options: qt_gui
    id: HOST_zmq_plutoSDR_rx
    output_language: python
    title: HOST ZMQ PlutoSDR Reciever Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    nconnections: '2'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '2046'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"PlutoSDR"'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.1.119:20000
    timeout: '1000'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', qtgui_freq_sink_x_0, '1']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_pull_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

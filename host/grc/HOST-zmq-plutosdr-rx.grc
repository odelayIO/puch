options:
  parameters:
    generate_options: qt_gui
    id: HOST_zmq_plutoSDR_rx
    output_language: python
    title: HOST ZMQ PlutoSDR Reciever Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(868e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    nconnections: '2'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: '2046'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"PlutoSDR"'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.1.119:20000
    timeout: '1000'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://192.168.1.135:10000
    timeout: '1000'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', zeromq_push_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_freq_sink_x_0, '1']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '1']
- [zeromq_pull_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: HOST_simple_zmq_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: awgn_amp
  id: variable_qtgui_range
  parameters:
    label: AWGN Gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '10'
    step: '10'
    stop: samp_rate
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: '2046'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.1.233:20000
    timeout: '1000'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://192.168.1.13:10000
    timeout: '1000'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', zeromq_push_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

options:
  parameters:
    description: Simple GRC using PULL/PUSH on PYNQ-Z1 Board
    generate_options: no_gui
    id: PYNQ_ZMQ_FIFO_interface
    output_language: python
    title: odelayIO
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/xilinx/gnuradio/rx_dma
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/xilinx/gnuradio/tx_dma
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.1.135:10000
    timeout: '1000'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://192.168.1.119:20000
    timeout: '1000'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', zeromq_push_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_file_sink_0, '0']
- [zeromq_pull_source_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
